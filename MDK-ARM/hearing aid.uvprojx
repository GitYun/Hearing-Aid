# Keil uVision project hearing aid.uvprojx, settings and files
target hearing aid (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F302K8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: hearing aid
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F302x8
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Inc;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include;..\App\Inc;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;..\Drivers\WM8974;..\Middlewares\User\virtual_i2c;..\Drivers\Keys
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --diag_suppress=L6329
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_core.c usbd_ioreq.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Application/MDK-ARM
    ./: startup_stm32f302x8.s
  group Application/User
    ../Src/: usbd_dfu_if.c usb_device.c stm32f3xx_it.c usbd_desc.c stm32f3xx_hal_msp.c usart.c main.c i2s.c i2c.c usbd_conf.c gpio.c dma.c crc.c freertos.c iwdg.c
  group App
    ../App/Src/: batLed.c wm8974_audio.c audioStream.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_pcd.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_crc.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_tim.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_i2s.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_gpio.c stm32f3xx_hal_iwdg.c
  group Drivers/User
    ../Middlewares/User/virtual_i2c/: virtual_i2c.c
    ../Drivers/WM8974/: wm89xx.c wm8974.c
    ../Drivers/Keys/: keys.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c queue.c tasks.c event_groups.c croutine.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.1.0
